Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0]
File name: 0001
Time: 2022-07-19T20:01:13
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20170223_1515(x64) - Exporter 18.4.0.0 - Alternate UI 18.4.0.0
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Jul 19 20:01:13 2022 * Host: DESKTOP-4UM54TC * Database: C:\Users\Vlad\AppData\Local\Temp\{763C0FDC-22DD-46CE-8A45-1CF800984FAE}\ifc * Database version: 5507 * Database creation date: Tue Jul 19 20:01:12 2022 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Jul 19 20:01:12 2022 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Jul 19 20:01:12 2022 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Project Name; Phase: Project Status

# IfcSite, Default
RefLatitude: 42, 21, 31, 181945; RefLongitude: -71, -3, -24, -263305; RefElevation: 0 mm
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuilding
Other - Category: Project Information; Client Name: Owner; Project Address: Enter address here; Project Issue Date: Issue Date; Project Name: Project Name; Project Number: 0001; Project Status: Project Status

# IfcBuildingStorey: Level:8mm Head, Level 1
LongName: Level 1; Elevation: 0 mm
Other(Type) - Category: Levels; Family Name: Level
Identity Data(Type) - Type Name: 8mm Head
Graphics(Type) - Color: 0; Line Pattern: Centre; Line Weight: 1; Symbol: M_Level Head - Circle: M_Level Head - Circle; Symbol at End 1 Default: no; Symbol at End 2 Default: yes
Constraints(Type) - Elevation Base: Project Base Point
Constraints - Elevation: 0 mm
Dimensions - Computation Height: 0 mm
Identity Data - Building Story: yes; Name: Level 1; Structural: no
Other - Category: Levels; Family: Level: 8mm Head; Family and Type: Level: 8mm Head; Type: Level: 8mm Head; Type Id: Level: 8mm Head

# IfcDistributionPort (2)
Description: Flow; FlowDirection: SOURCE

# IfcFlowController: 1530F Kitchen faucet, 1530F(2020):1530F Kitchen faucet:295002
In: Level 1
Type - PredefinedType: FAUCET; Material: Brass
Type - Dimensions - InletConnectionSize: 10 mm; NominalDepth: 255 mm; NominalHeight: 168 mm; NominalWidth: 51 mm
Type - General - Author: BIMStone; BIMObjectName: 1530F(2020); ManufacturerName: Oras; ManufacturerURL: http://www.oras.com; NBSDescription: Water supply fittings for wash basins and troughs; NBSReference: 45-35-70/371; ProductInformation: n/a; Revision: 3; Uniclass2: Pr_40_30_96_96; Uniclass2015Description: Washbasin manual water supply sets; Uniclass2015Reference: Pr_40_20_87_96; Version: 3; VersionDate: 01/07/2022
Type - Green Building Properties - Approval KIWA SE Type Approval: 1445; EAN Number: 6414150085727; EN Standard: EN 817; ETIM Class Number: EC011431 Kitchen mixing tap; Noise Class: I (ISO 3822) Oras lab.; RSK Number: 8310603; Sales Package dimensions (LxWxH): 362 x 278 x 63; UNSPSC Class Number: 30181700 Faucets or taps; URL Declaration of Conformity: http://static.oras.com/DoC/1530F; URL KIWA SE Type Approval: http://static.oras.com/KIWASETypeApproval/1530F; URL REACH: http://static.oras.com/doc/reach; VVS Number: 705917604
Type - Identity Data - 2D/3D/BIM Files URL: http://static.oras.com/bim/1530F; 3D View: https://static.oras.com/3D/1530F; Ambience photo: http://static.oras.com/ambience/1530F; Catalog Drawing URL: http://static.oras.com/catdrw/1530F; Dimension Drawing URL: http://static.oras.com/dimdrw/1530F; FDV Document URL: http://www.oras.com/datasheet/1530F/en/fdv; Flow Drawing URL: http://static.oras.com/flowchart/1530F; Group: Kitchen faucet; Installation and Maintenance Guide URL: http://static.oras.com/manual/1530F; Interactive AR View URL: https://static.oras.com/AR/1530F; Manufacturer: Oras; Market: International;Sweden;Denmark; Mobile Product Information URL: http://mpi.oras.com/1530F; Model: 1530F Kitchen faucet; Name_en: 1530F Kitchen faucet; OmniClass Number: 23.45.55.00; OmniClass Title: Sanitary Faucets, Wastes; Product Code: 1530F; Product Family: Oras Swea; Product Image URL: http://static.oras.com/image/1530F; Product URL: http://static.oras.com/1530F; Spare-Part Information URL: http://static.oras.com/sp/1530F; Technical DataSheet URL: http://www.oras.com/datasheet/1530F/en; Type Name: 1530F Kitchen faucet; Warranty Information URL: http://warranty.oras.com
Type - Materials and Finishes - FaucetMainMaterial: Brass
Type - Mechanical - Advanced Features: Rapid installation system; Aerator: Standard aerator; Backflow Prevention EN1717: AA; Connection: Flexible inlet pipes; Connection Size: G3/8; Eco Flow At 300kPa: 0.0275454 m3/s; Flow Rate At 300kPa: 0.00459091 m3/s; Installation Type: Deck mounted; Lever Handle: Single operating lever/handle;Hot/Cold symbols; Max. Hot Water Supply: 70 kg/K/s3; Mechanical Parts: ø 35 mm ceramic cartridge for flow and temperature control; Mounting Holes: 1 hole; Pressure Loss With Flow 01ls: 180000 Pa; Spout Projection: 215 mm; Spout Type: Swivel range limiting option; Surface treatment: Chrome; Temperature Adjustments: Limitation option for maximum temperature and flow-rate; Working Pressure: 50 - 1000 kPa
Type - Other - AccessibilityPerformance: n/a; AssetType: Fixed; Brand: Oras; Category: Kitchen; CodePerformance: n/a; Color: Chrome; Constituents: n/a; DurationUnit: Year; ExpectedLife: n/a; Family Name: 1530F(2020); Features: Single-lever; Finish: Polished; Grade: n/a; Material: Brass; ModelNumber: n/a; ModelReference: 1530F; Name: 1530F Kitchen faucet; ReplacementCost: n/a; Shape: Sculptured; Size: 50x255x170 mm; SustainabilityPerformance: n/a; WarrantyDescription: http://warranty.oras.com; WarrantyDurationLabor: n/a; WarrantyDurationParts: n/a; WarrantyDurationUnit: Year; WarrantyGuarantorLabor: n/a; WarrantyGuarantorParts: n/a
Constraints - DefaultElevation: 900 mm; Host: Level : Level 1; Level: Level: Level 1; Offset: 0 mm
Dimensions - Area: 0.0655125 m2; Volume: 0.00218955 m3
Identity Data - Mark: 1
Mechanical - System Classification: Domestic Hot Water,Domestic Cold Water
Other - AssetIdentifier: n/a; Barcode: n/a; Category: Plumbing Fixtures; Family: 1530F(2020): 1530F Kitchen faucet; Family and Type: 1530F(2020): 1530F Kitchen faucet; InstallationDate: n/a; SerialNumber: n/a; TagNumber: n/a; Type: 1530F(2020): 1530F Kitchen faucet; Type Id: 1530F(2020): 1530F Kitchen faucet; WarrantyStartDate: n/a
Phasing - Phase Created: Phase 1
